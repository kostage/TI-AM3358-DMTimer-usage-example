## Kconfig
```kconfig
config PEL_DMTIMER_DRV
	tristate "DMTIMER dummy example"
	help
		Simply toggles pin
```
